<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\DMX512_F103RCT.ewp</path>
  </project>
  <batchBuild />
</workspace>
